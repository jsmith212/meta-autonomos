require recipes-images/base/autonomos-base.bb
require recipes-core/images/core-image-base.bb
