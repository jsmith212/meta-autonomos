IMAGE_BASENAME:append = "-${DISTRO_CODENAME}"

require recipes-images/base/autonomos-common.inc
